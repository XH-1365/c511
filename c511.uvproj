# Keil uVision project c511.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: c511 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Sys\Inc
  group User
    ./User/: main.c
  group Sys
    ./Sys/: sys.c 138.c uln2003.c
